# Keil uVision project test.uvprojx, settings and files
target test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c misc: --cpp11
  c include: ..\..\f030_cpp_demo;..\..\..\libmcu\F0\STM32F0xx_HAL_Driver\Inc;..\..\..\libmcu\F0\hal_cpp;..\..\..\libmcu\F0\cmsis\math;..\..\..\libmcu\F0\STM32F0xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ../../../libmcu/F0/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_spi.c
    ../: mian.cpp system_stm32f0xx.c stm32f0xx_it.cpp
    ./: keil_startup_stm32f030x6.s
    ../../../libmcu/F0/hal_cpp/: gpio.h ssd1306.cpp font.cpp font.h spi.h ssd1306.h
